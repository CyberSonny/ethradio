# IAR project NikeE1B.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x60
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\$TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-standard,(XDATA)=.ee.hex; -Oraw-binary,(XDATA)=.ee.bin
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  prebuild: SubWCRev.exe $PROJ_DIR$ revision.tmpl revision.c
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm168.xcl
  XLINK.XExtraOptions: -Z(CODE)RJMP_FLASH=_..X_INTVEC_SIZE-FFF; -KEEPROM_I=AA,1; -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: compiler.h ethernet.h http_get.c http_get.h http_srv.h mac.c main.c md5cheat.c network.c network.h nike_e.h player.h station.c station.h stdafx.h stuff.asm tcp.h
  group ENC28j60
    ./: enc28j60.c enc28j60.h nic.c nic.h
  group FIFO
    ./: FIFO.c FIFO.h
  group HTTP
    ./: pages.c pages.h
  group KEYSCAN
    ./: kb.c kb.h
  group LCD
    ./: lcd.c lcd.h
  group USART
    ./: io.c io.h
  group VS
    ./: vs.c vs.h
